Commit message: hit xylophone okay, sometimes stick gets stuck in between nodes

File: src/system_launch/models/stick.urdf (robot description, URDF)
Before this commit: robot stick, 1 links, 0 joints
Links:
- link stick: mass 0.20 -> 0.00
